# Keil uVision project classA.uvprojx, settings and files
target RAK811_breakboard (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: classA +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin Objects\classA.axf --output classA.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_EU868
  c include: ..\..\src;..\..\src\boards\RAK811BreakBoard;..\..\src\boards\RAK811BreakBoard\cmsis;..\..\src\boards\mcu\stm32;..\..\src\boards\mcu\stm32\cmsis;..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\Inc;..\..\src\mac;..\..\src\mac\region;..\..\src\peripherals;..\..\src\radio;..\..\src\system;..\..\src\system\crypto;..\classA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../../src/apps/classA/: main.c
  group boards\RAK811BreakBoard
    ../../src/boards/RAK811BreakBoard/: adc-board.c gpio-board.c gps-board.c i2c-board.c rtc-board.c board.c spi-board.c sx1276-board.c uart-board.c
    ./: bsp_dht11.c
  group boards\RAK811BreakBoard\cmsis
    ../../src/boards/RAK811BreakBoard/cmsis/: system_stm32l1xx.c
    ../../src/boards/RAK811BreakBoard/cmsis/arm-std/: startup_stm32l151xb.s
  group boards\mcu\stm32\STM32L1xx_HAL_Driver
    ../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_cortex.c
  group boards\mcu\stm32
    ../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group mac
    ../../src/mac/: LoRaMac.c LoRaMacCrypto.c
  group mac\region
    ../../src/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCommon.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
  group peripherals
    ../../src/peripherals/: lis3dh.c
  group radio
    ../../src/radio/sx1276/: sx1276.c
  group system
    ../../src/system/: adc.c delay.c fifo.c gpio.c gps.c i2c.c timer.c uart.c
  group system\crypto
    ../../src/system/crypto/: aes.c cmac.c
